options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Hardware tutorial
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF GAIN
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    start: '1000000'
    step: 1e3
    stop: '50000000'
    value: '20000000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 80e6
    step: 200e3
    stop: 100e6
    value: 90e6
    widget: slider
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '10000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Off'''
    frequency: '100000000'
    gain1: '''manual'''
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:pluto.local
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    name: Spectrum Analyzer
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    name: Spectrum Analyzer
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: tuning
    dev_args: '""'
    gain0: rf_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [iio_pluto_source_0, '0', qtgui_sink_x_0_0, '0']
- [qtgui_sink_x_0, freq, qtgui_sink_x_0, freq]
- [qtgui_sink_x_0, freq, uhd_usrp_source_0, command]
- [qtgui_sink_x_0_0, freq, qtgui_sink_x_0_0, freq]
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Hardware tutorial
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF GAIN
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    start: 192e3
    step: 1e3
    stop: 56e6
    value: '3840000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 70e6
    step: 200e3
    stop: 6e9
    value: '102100000'
    widget: slider
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    name: Spectrum Analyzer
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: tuning
    gain0: rf_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [qtgui_sink_x_0, freq, qtgui_sink_x_0, freq]
- [qtgui_sink_x_0, freq, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
